Commit message: Add files via upload

File: model.urdf (robot description, URDF)
Before this commit: robot block, 1 links, 0 joints
Links:
- removed link sphere
- added link reference, mass 0.5; collision cylinder length=0.01 radius=0.025; visual cylinder length=0.01 radius=0.025
